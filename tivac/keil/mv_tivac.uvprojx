# Keil uVision project mv_tivac.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mv_tivac
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\repo\Src\Common;.\repo\Src\Config;.\repo\Src\Mcal\Inc;.\repo\Src\Config
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Appl
    ./repo/Src/Appl/: main.c
  group Config
    ./repo/Src/Config/: tm4c123gh6pm.h TYPES.h
  group MCAL
    ./repo/Src/Mcal/: STK.c GPIO.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.1
